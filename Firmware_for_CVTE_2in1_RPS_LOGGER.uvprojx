# Keil uVision project Firmware_for_CVTE_2in1_RPS_LOGGER.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Firmware_for_CVTE_2in1_RPS_LOGGER
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ./: app.h timebase.h dispcom.h display.h tm1650.h cdef.h captouch.c diag.h dispfnc.h debug.h
  group src
    ./: main.c app.c timebase.c dispcom.c display.c tm1650.c cdef.c captouch.h diag.c dispfnc.c debug.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.4.2
